# Keil uVision project FQ.uvprojx, settings and files
target FQ (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ME32G030AF8P6 Mesilicon
  pack: Mesilicon.ME32.2.3.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lamp_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=167,1296
  c include: ..\User;..\common\CMSIS\Include;..\common\Device\ARM\ME32G030\Include
  library: MicroLIB
  memory RVCT4: ROM 0xc00 size 0x6400
  memory RVCT9: RAM 0x10000000 size 0x2000
  group USER
    ../User/: Main.c driver_uart.c eeprom_driver.c error_code.c flash_driver.c iap.c lamp_app.c lamp_driver.c log_printf.c my_utility.c nvs_data.c port_higherlayer.c soft_timer.c struct_light.c struct_light_driver.c checksum.c protocol_app.c
    ./: me32g030_adc.c DimmingAlgorithm.c
  group comm
    ../common/CMSIS/Include/: core_cm0.c
    ../common/Device/ARM/ME32G030/Source/: system_me32g030.c me32g030_sys.c me32g030_pwm.c me32g030_uart.c
    ../common/Device/ARM/ME32G030/Source/ARM/: startup_me32g030.s
